<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\OFFICE_CLOCK_SURYA.ewp</path>
  </project>
  <batchBuild />
</workspace>
