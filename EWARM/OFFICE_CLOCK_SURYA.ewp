# IAR project OFFICE_CLOCK_SURYA.ewp, settings and files
configuration OFFICE_CLOCK_SURYA (ARM, debug)
  General.OGChipSelectEditMenu: STM32G030C8 ST STM32G030C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32G030xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OFFICE_CLOCK_SURYA.hex
  ILINK.IlinkOutputFile: OFFICE_CLOCK_SURYA.out
  ILINK.IlinkIcfFile: stm32g030xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g030xx.s
  group Application/User/Core
    ../Core/Src/: App_Init.c App_RAM.c gpio.c I2C_RTC.c iwdg.c main.c Misc_Functions.c rtc.c stm32g0xx_hal_msp.c stm32g0xx_it.c SW_I2C.c tim.c usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_rtc.c stm32g0xx_hal_rtc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_ll_dma.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_rcc.c stm32g0xx_ll_usart.c stm32g0xx_ll_utils.c
